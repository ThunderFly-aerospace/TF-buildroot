## package/mavlink-router/Config.in
```kconfig
config BR2_PACKAGE_MAVLINK_ROUTER
    bool "mavlink-router"
    help
        Mavlink-router package.
```
